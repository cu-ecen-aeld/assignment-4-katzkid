## base_external/Config.in
```kconfig
# File: base_external/Config.in
source "../base_external/package/aesd-assignments/Config.in"
```
